# IAR project device-creds.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: efr32mg24a020f1536gm48 SiliconLaboratories efr32mg24a020f1536gm48
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG_EFM=1; MATTER_X509_EXTENSIONS=1; EFR32MG24A020F1536GM48=1; SL_BOARD_NAME="BRD4187A"; SL_BOARD_REV="A02"; SL_COMPONENT_CATALOG_PRESENT=1; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $FILE_DIR$; config; autogen; ..; ..\..\..\..\..\..\..\git\gsdk\platform\Device\SiliconLabs\EFR32MG24\Include; ..\..\..\..\..\..\..\git\gsdk\platform\common\inc; ..\..\..\..\..\..\..\git\gsdk\hardware\board\inc; ..\..\..\..\..\..\..\git\gsdk\platform\CMSIS\Core\Include; ..\..\..\..\..\..\..\git\gsdk\hardware\driver\configuration_over_swo\inc; ..\..\..\..\..\..\..\git\gsdk\platform\driver\debug\inc; ..\..\..\..\..\..\..\git\gsdk\platform\service\device_init\inc; ..\..\..\..\..\..\..\git\gsdk\platform\emdrv\common\inc; ..\..\..\..\..\..\..\git\gsdk\platform\emlib\inc; ..\..\..\..\..\..\..\git\gsdk\platform\service\iostream\inc; ..\..\..\..\..\..\..\git\gsdk\util\third_party\crypto\mbedtls\include; ..\..\..\..\..\..\..\git\gsdk\util\third_party\crypto\mbedtls\library; ..\..\..\..\..\..\..\git\gsdk\util\third_party\crypto\sl_component\sl_mbedtls_support\config; ..\..\..\..\..\..\..\git\gsdk\util\third_party\crypto\sl_component\sl_mbedtls_support\inc; ..\..\..\..\..\..\..\git\gsdk\hardware\driver\mx25_flash_shutdown\inc\sl_mx25_flash_shutdown_eusart; ..\..\..\..\..\..\..\git\gsdk\platform\emdrv\nvm3\inc; ..\..\..\..\..\..\..\git\gsdk\util\third_party\crypto\sl_component\sl_psa_driver\inc; ..\..\..\..\..\..\..\git\gsdk\util\third_party\crypto\sl_component\sl_psa_driver\inc\public; ..\..\..\..\..\..\..\git\gsdk\util\third_party\crypto\sl_component\se_manager\inc; ..\..\..\..\..\..\..\git\gsdk\util\third_party\crypto\sl_component\se_manager\src; ..\..\..\..\..\..\..\git\gsdk\util\silicon_labs\silabs_core\memory_manager; ..\..\..\..\..\..\..\git\gsdk\platform\common\toolchain\inc; ..\..\..\..\..\..\..\git\gsdk\platform\service\system\inc; ..\..\..\..\..\..\..\git\gsdk\platform\service\udelay\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device-creds.s37
  ILINK.IlinkOutputFile: device-creds.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: device-creds.ipcf
