# IAR project device-creds.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG24B210F1536IM48 SiliconLaboratories EFR32MG24B210F1536IM48
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: MATTER_COMMON_NAME="Matter Dev DAC 0xFFF1/0x8005"; MATTER_PRODUCT_ID=0x8005; MATTER_VENDOR_ID=0xFFF1; MATTER_X509_EXTENSIONS=1; PSA_CRYPTO_PRINT=1; PSA_CRYPTO_PRINT_CERT=1; RESERVED_AVAILABLE_MEMORY=1000; EFR32MG24B210F1536IM48=1; SL_APP_PROPERTIES=1; SL_BOARD_NAME="BRD4186C"; SL_BOARD_REV="A01"; SL_COMPONENT_CATALOG_PRESENT=1; SEGGER_RTT_ALIGNMENT=1024; EMBER_AF_API_BOOTLOADER_INTERFACE=1; CORTEXM3=1; CORTEXM3_EFM32_MICRO=1; CORTEXM3_EFR32=1; PHY_RAIL=1; PLATFORM_HEADER="platform-header.h"; SL_LEGACY_HAL_ENABLE_WATCHDOG=1; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; SL_RAIL_LIB_MULTIPROTOCOL_SUPPORT=0; SL_RAIL_UTIL_PA_CONFIG_HEADER=<sl_rail_util_pa_config.h>; RTT_USE_ASM=0; CUSTOM_TOKEN_HEADER="sl_token_manager_af_token_header.h"; USE_NVM3=1; UC_BUILD=1; EMBER_AF_NCP=1; EMBER_SERIAL1_RTSCTS=1; EZSP_UART=1; NO_USB=1; EMBER_MULTI_NETWORK_STRIPPED=1; SL_ZIGBEE_PHY_SELECT_STACK_SUPPORT=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $FILE_DIR$; config; autogen; ..; ..\..\common; ..\..\..\..\..\..\..\Green\git\gsdk\platform\Device\SiliconLabs\EFR32MG24\Include; ..\..\..\..\..\..\..\Green\git\gsdk\platform\common\inc; ..\..\..\..\..\..\..\Green\git\gsdk\hardware\board\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\bootloader; ..\..\..\..\..\..\..\Green\git\gsdk\platform\bootloader\api; ..\..\..\..\..\..\..\Green\git\gsdk\platform\CMSIS\Core\Include; ..\..\..\..\..\..\..\Green\git\gsdk\hardware\driver\configuration_over_swo\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\driver\debug\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\service\device_init\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\emdrv\common\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\emlib\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\service\hfxo_manager\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\service\iostream\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\driver\leddrv\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\service\legacy_hal\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\service\legacy_common_ash\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\service\legacy_hal_wdog\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\service\legacy_ncp_ash\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\service\legacy_printf\inc; ..\..\..\..\..\..\..\Green\git\gsdk\util\third_party\crypto\mbedtls\include; ..\..\..\..\..\..\..\Green\git\gsdk\util\third_party\crypto\mbedtls\library; ..\..\..\..\..\..\..\Green\git\gsdk\util\third_party\crypto\sl_component\sl_mbedtls_support\config; ..\..\..\..\..\..\..\Green\git\gsdk\util\third_party\crypto\sl_component\sl_mbedtls_support\inc; ..\..\..\..\..\..\..\Green\git\gsdk\hardware\driver\mx25_flash_shutdown\inc\sl_mx25_flash_shutdown_eusart; ..\..\..\..\..\..\..\Green\git\gsdk\platform\emdrv\nvm3\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\peripheral\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\service\power_manager\inc; ..\..\..\..\..\..\..\Green\git\gsdk\util\third_party\printf; ..\..\..\..\..\..\..\Green\git\gsdk\util\third_party\printf\inc; ..\..\..\..\..\..\..\Green\git\gsdk\util\third_party\crypto\sl_component\sl_psa_driver\inc; ..\..\..\..\..\..\..\Green\git\gsdk\util\third_party\crypto\sl_component\sl_psa_driver\inc\public; ..\..\..\..\..\..\..\Green\git\gsdk\platform\radio\rail_lib\common; ..\..\..\..\..\..\..\Green\git\gsdk\platform\radio\rail_lib\protocol\ble; ..\..\..\..\..\..\..\Green\git\gsdk\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\..\..\..\..\Green\git\gsdk\platform\radio\rail_lib\protocol\zwave; ..\..\..\..\..\..\..\Green\git\gsdk\platform\radio\rail_lib\chip\efr32\efr32xg2x; ..\..\..\..\..\..\..\Green\git\gsdk\platform\radio\rail_lib\plugin\rail_util_ieee802154; ..\..\..\..\..\..\..\Green\git\gsdk\platform\radio\rail_lib\plugin\pa-conversions; ..\..\..\..\..\..\..\Green\git\gsdk\platform\radio\rail_lib\plugin\pa-conversions\efr32xg24; ..\..\..\..\..\..\..\Green\git\gsdk\platform\radio\rail_lib\plugin\rail_util_pti; ..\..\..\..\..\..\..\Green\git\gsdk\util\third_party\crypto\sl_component\se_manager\inc; ..\..\..\..\..\..\..\Green\git\gsdk\util\third_party\crypto\sl_component\se_manager\src; ..\..\..\..\..\..\..\Green\git\gsdk\util\third_party\segger\systemview\SEGGER; ..\..\..\..\..\..\..\Green\git\gsdk\util\silicon_labs\silabs_core\memory_manager; ..\..\..\..\..\..\..\Green\git\gsdk\platform\common\toolchain\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\service\system\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\service\sleeptimer\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\service\token_manager\inc; ..\..\..\..\..\..\..\Green\git\gsdk\platform\service\udelay\inc; ..\..\..\..\..\..\..\Green\git\gsdk\protocol\zigbee\stack\platform\micro; ..\..\..\..\..\..\..\Green\git\gsdk\protocol\zigbee\stack\include; ..\..\..\..\..\..\..\Green\git\gsdk\protocol\zigbee\app\framework\common; ..\..\..\..\..\..\..\Green\git\gsdk\protocol\zigbee\app\em260; ..\..\..\..\..\..\..\Green\git\gsdk\protocol\zigbee\stack\framework; ..\..\..\..\..\..\..\Green\git\gsdk\protocol\zigbee\app\framework\plugin\debug-print; ..\..\..\..\..\..\..\Green\git\gsdk\protocol\zigbee\stack\gp; ..\..\..\..\..\..\..\Green\git\gsdk\protocol\zigbee\app\xncp; ..\..\..\..\..\..\..\Green\git\gsdk\protocol\zigbee\app\util\ezsp; ..\..\..\..\..\..\..\Green\git\gsdk\protocol\zigbee\app\framework\util; ..\..\..\..\..\..\..\Green\git\gsdk\protocol\zigbee\app\util\security; ..\..\..\..\..\..\..\Green\git\gsdk\platform\radio\rail_lib\plugin; ..\..\..\..\..\..\..\Green\git\gsdk\protocol\zigbee; ..\..\..\..\..\..\..\Green\git\gsdk\protocol\zigbee\stack; ..\..\..\..\..\..\..\Green\git\gsdk\protocol\zigbee\stack\zigbee; ..\..\..\..\..\..\..\Green\git\gsdk\platform\radio\mac\rail_mux; ..\..\..\..\..\..\..\Green\git\gsdk\platform\radio\mac; ..\..\..\..\..\..\..\Green\git\gsdk\util\silicon_labs\silabs_core; ..\..\..\..\..\..\..\Green\git\gsdk\protocol\zigbee\stack\core; ..\..\..\..\..\..\..\Green\git\gsdk\protocol\zigbee\stack\mac; ..\..\..\..\..\..\..\Green\git\gsdk\protocol\zigbee\app\ncp\plugin\xncp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device-creds.s37
  ILINK.IlinkOutputFile: device-creds.out
  ILINK.IlinkIcfFile: autogen\linkerfile_base.icf
  group (top)
    ./: device-creds.ipcf
