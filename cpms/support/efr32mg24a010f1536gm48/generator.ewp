# IAR project generator.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: efr32mg24a010f1536gm48 SiliconLaboratories efr32mg24a010f1536gm48
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: CUSTOM_TOKEN_HEADER=custom-tokens.h; EFR32MG24A010F1536GM48=1; SL_COMPONENT_CATALOG_PRESENT=1; MBEDTLS_CONFIG_FILE=<sl_mbedtls_config.h>; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; RTT_USE_ASM=0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $FILE_DIR$; config; autogen; ..\..\generator; ..\..\..\examples; ..\..\..\src; ..\..\..\third_party\silabs\gecko_sdk\platform\Device\SiliconLabs\EFR32MG24\Include; ..\..\..\third_party\silabs\gecko_sdk\platform\CMSIS\Core\Include; ..\..\..\third_party\silabs\gecko_sdk\platform\service\device_init\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\emdrv\common\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\emlib\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\common\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\service\iostream\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\security\sl_component\sl_mbedtls_support\config; ..\..\..\third_party\silabs\gecko_sdk\platform\security\sl_component\sl_mbedtls_support\inc; ..\..\..\third_party\silabs\gecko_sdk\util\third_party\mbedtls\include; ..\..\..\third_party\silabs\gecko_sdk\util\third_party\mbedtls\library; ..\..\..\third_party\silabs\gecko_sdk\platform\emdrv\nvm3\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\security\sl_component\sl_psa_driver\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\security\sl_component\sl_psa_driver\inc\public; ..\..\..\third_party\silabs\gecko_sdk\platform\security\sl_component\se_manager\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\security\sl_component\se_manager\src; ..\..\..\third_party\silabs\gecko_sdk\util\third_party\segger\systemview\SEGGER; ..\..\..\third_party\silabs\gecko_sdk\util\silicon_labs\silabs_core\memory_manager; ..\..\..\third_party\silabs\gecko_sdk\platform\common\toolchain\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\service\system\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: generator.s37
  ILINK.IlinkOutputFile: generator.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: generator.ipcf
