# IAR project generator.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG24A010F1024IM48 SiliconLaboratories EFR32MG24A010F1024IM48
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: EFR32MG24A010F1024IM48=1; SL_COMPONENT_CATALOG_PRESENT=1; MBEDTLS_CONFIG_FILE=<sl_mbedtls_config.h>; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; RTT_USE_ASM=0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $FILE_DIR$; config; autogen; ..\..\generator; ..\..\..\examples; ..\..\..\src; ..\..\..\..\..\..\..\git\gsdk\platform\Device\SiliconLabs\EFR32MG24\Include; ..\..\..\..\..\..\..\git\gsdk\platform\CMSIS\Core\Include; ..\..\..\..\..\..\..\git\gsdk\platform\emdrv\common\inc; ..\..\..\..\..\..\..\git\gsdk\platform\emlib\inc; ..\..\..\..\..\..\..\git\gsdk\platform\common\inc; ..\..\..\..\..\..\..\git\gsdk\platform\service\iostream\inc; ..\..\..\..\..\..\..\git\gsdk\platform\security\sl_component\sl_mbedtls_support\config; ..\..\..\..\..\..\..\git\gsdk\platform\security\sl_component\sl_mbedtls_support\config\preset; ..\..\..\..\..\..\..\git\gsdk\platform\security\sl_component\sl_mbedtls_support\inc; ..\..\..\..\..\..\..\git\gsdk\util\third_party\mbedtls\include; ..\..\..\..\..\..\..\git\gsdk\util\third_party\mbedtls\library; ..\..\..\..\..\..\..\git\gsdk\platform\emdrv\nvm3\inc; ..\..\..\..\..\..\..\git\gsdk\platform\security\sl_component\sl_psa_driver\inc; ..\..\..\..\..\..\..\git\gsdk\platform\security\sl_component\se_manager\inc; ..\..\..\..\..\..\..\git\gsdk\platform\security\sl_component\se_manager\src; ..\..\..\..\..\..\..\git\gsdk\util\third_party\segger\systemview\SEGGER; ..\..\..\..\..\..\..\git\gsdk\util\silicon_labs\silabs_core\memory_manager; ..\..\..\..\..\..\..\git\gsdk\platform\common\toolchain\inc; ..\..\..\..\..\..\..\git\gsdk\platform\service\system\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: generator.s37
  ILINK.IlinkOutputFile: generator.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: generator.ipcf
